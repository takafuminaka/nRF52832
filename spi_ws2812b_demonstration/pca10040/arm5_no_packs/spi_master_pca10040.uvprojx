# Keil uVision project spi_master_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\config\spi_master_pca10040;..\..\config;..\..\ws2812b_driver;..\..;..\..\..\..\bsp;..\..\..\..\..\components\drivers_nrf\spi_master;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c flashing_random.c running_rainbow.c running_rainbowv.c
  group Board Support
    ../../../../bsp/: bsp.c
  group Documentation
    ../../: LICENSE README.md
  group nRF_Drivers
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group nRF_Libraries
    ../../../../../components/libraries/button/: app_button.c
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/timer/: app_timer.c
  group ws2812b_driver
    ../../ws2812b_driver/: ws2812b_driver.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
